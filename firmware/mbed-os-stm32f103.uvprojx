# Keil uVision project mbed-os-stm32f103.uvprojx, settings and files
target mbed-os-stm32f103 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mbed-os-stm32f103
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER,STM32F105xC
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -D__ASSERT_MSG -DTARGET_STM32F1 --no_rtti -DTARGET_STM32F103RB -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DTARGET_FF_ARDUINO -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DTARGET_NUCLEO_F103RB -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M3 -DTARGET_FF_MORPHO -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DMBED_BUILD_TIMESTAMP=1480518831.38 -DDEVICE_SERIAL=1 -DTARGET_M3 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM -DTARGET_LIKE_MBED
  c include: .;img;mbed-os/.;mbed-os/docs;mbed-os/features;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/greentea-client/greentea-client;mbed-os/features/frameworks/greentea-client/source;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/unity/source;mbed-os/features/frameworks/unity/unity;mbed-os/features/frameworks/utest;mbed-os/features/frameworks/utest/source;mbed-os/features/frameworks/utest/utest;mbed-os/features/mbedtls;mbed-os/features/mbedtls/importer;mbed-os/features/mbedtls/inc;mbed-os/features/mbedtls/inc/mbedtls;mbed-os/features/mbedtls/src;mbed-os/features/mbedtls/platform;mbed-os/features/mbedtls/platform/inc;mbed-os/features/mbedtls/platform/src;mbed-os/features/nanostack;mbed-os/features/storage;mbed-os/features/netsocket;mbed-os/cmsis;mbed-os/drivers;mbed-os/events;mbed-os/events/equeue;mbed-os/rtos;mbed-os/rtos/rtx;mbed-os/rtos/rtx/TARGET_CORTEX_M;mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3;mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM;mbed-os/hal;mbed-os/hal/hal;mbed-os/hal/storage_abstraction;mbed-os/platform;mbed-os/targets;mbed-os/targets/TARGET_STM;mbed-os/targets/TARGET_STM/TARGET_STM32F1;mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB;mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device;mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/TOOLCHAIN_ARM_STD;mbed-os/targets/TARGET_STM/TARGET_STM32F1/device;.\mbed-os\targets\TARGET_STM\TARGET_STM32F1\STM32_USB_Host_Library\Class\MSC\Inc;.\mbed-os\targets\TARGET_STM\TARGET_STM32F1\STM32_USB_Host_Library\Core\Inc;.\mbed-os\targets\TARGET_STM\TARGET_STM32F1\STM32_USB_Host_Library;.\mbed-os\features\FATFileSystem\FatFs\src;.\mbed-os\features\FATFileSystem\FatFs\src\drivers;.\mbed-os\features\FATFileSystem\FatFs\src\option;.\mbed-os\features\FATFileSystem;.\ampm_lib;.\ampm_lib\ampm_gsm;.\ampm_lib\ampm_gsm\sms;.\ampm_lib\common;EthernetInterface;EthernetInterface/Socket;EthernetInterface/lwip-eth;EthernetInterface/lwip-eth/arch;EthernetInterface/lwip-sys;EthernetInterface/lwip-sys/arch;EthernetInterface/lwip;EthernetInterface/lwip/api;EthernetInterface/lwip/core;EthernetInterface/lwip/core/ipv4;EthernetInterface/lwip/core/snmp;EthernetInterface/lwip/include;EthernetInterface/lwip/include/ipv4;EthernetInterface/lwip/include/ipv4/lwip;EthernetInterface/lwip/include/lwip;EthernetInterface/lwip/include/netif;EthernetInterface/lwip/netif;EthernetInterface/lwip/netif/ppp
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M3,-D__CMSIS_RTOS,-DARM_MATH_CM3,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\mbed-os\targets\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB\device\TOOLCHAIN_ARM_STD\stm32f105vc.sct
  group TARGET_CORTEX_M
    mbed-os/rtos/rtx/TARGET_CORTEX_M/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_OsEventObserver.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c RTX_Conf_CM.c
    ./obj/: hal_cm.o rt_cmsis.o rt_event.o rt_list.o rt_mailbox.o rt_membox.o rt_memory.o rt_mutex.o rt_oseventobserver.o rt_robin.o rt_semaphore.o rt_system.o rt_task.o rt_time.o rt_timer.o rtx_conf_cm.o
  group TARGET_NUCLEO_F103RB
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: objects.h PeripheralNames.h PeripheralPins.c PinNames.h PortNames.h
  group TARGET_STM
    mbed-os/targets/TARGET_STM/: mbed_rtx.h stm_spi_api.c trng_api.c
  group TARGET_STM32F1
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/: analogin_api.c can_api.c gpio_api.c gpio_irq_api.c i2c_api.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    ./obj/: gpio_api.o mbed_overrides.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o us_ticker.o analogin_api.o gpio_irq_api.o i2c_api.o can_api.o
  group TOOLCHAIN_ARM
    mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.S
    ./obj/: hal_cm3.o
  group TOOLCHAIN_ARM_STD
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/TOOLCHAIN_ARM_STD/: sys.cpp
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/TOOLCHAIN_ARM_STD/: startup_stm32f105xc.s
  group USBH
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F1/STM32_USB_Host_Library/obj/: usb_host.o usbh_conf.o usbh_core.o usbh_ctlreq.o usbh_diskio.o usbh_ioreq.o usbh_msc.o usbh_msc_bot.o usbh_msc_scsi.o usbh_pipes.o usbhostmsd.o
    ./mbed-os/features/FATFileSystem/FatFs/src/drivers/: usbh_diskio.c
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F1/STM32_USB_Host_Library/: usb_host.c usbh_conf.c
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F1/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F1/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group FATFileSystem
    ./mbed-os/features/FATFileSystem/obj/: ccsbcs.o syscall.o
    ./mbed-os/features/FATFileSystem/FatFs/src/: ff.c diskio.cpp
    ./mbed-os/features/FATFileSystem/: SDCard.cpp FATDirHandle.cpp FATFileHandle.cpp FATFileSystem.cpp
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F1/STM32_USB_Host_Library/: USBHostMSD.cpp
    ./mbed-os/features/FATFileSystem/FatFs/src/option/: syscall.c unicode.c
  group device
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/TOOLCHAIN_ARM_STD/: stm32f1xx_hal_usart.o stm32f1xx_hal_uart.o stm32f1xx_hal.o stm32f1xx_hal_adc.o stm32f1xx_hal_adc_ex.o stm32f1xx_hal_can.o stm32f1xx_hal_cec.o stm32f1xx_hal_cortex.o stm32f1xx_hal_crc.o stm32f1xx_hal_dac.o stm32f1xx_hal_dac_ex.o stm32f1xx_hal_dma.o stm32f1xx_hal_eth.o stm32f1xx_hal_flash.o stm32f1xx_hal_flash_ex.o stm32f1xx_hal_gpio.o stm32f1xx_hal_gpio_ex.o stm32f1xx_hal_hcd.o stm32f1xx_hal_i2c.o stm32f1xx_hal_i2s.o stm32f1xx_hal_irda.o stm32f1xx_hal_iwdg.o stm32f1xx_hal_msp.o stm32f1xx_hal_nand.o stm32f1xx_hal_nor.o stm32f1xx_hal_pccard.o stm32f1xx_hal_pcd.o stm32f1xx_hal_pcd_ex.o stm32f1xx_hal_pwr.o stm32f1xx_hal_rcc.o stm32f1xx_hal_rcc_ex.o stm32f1xx_hal_rtc.o stm32f1xx_hal_rtc_ex.o stm32f1xx_hal_sd.o stm32f1xx_hal_smartcard.o stm32f1xx_hal_spi.o stm32f1xx_hal_spi_ex.o stm32f1xx_hal_sram.o stm32f1xx_hal_tim.o stm32f1xx_hal_tim_ex.o stm32f1xx_hal_wwdg.o stm32f1xx_ll_fsmc.o stm32f1xx_ll_sdmmc.o stm32f1xx_ll_usb.o
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/: cmsis.h cmsis_nvic.c cmsis_nvic.h hal_tick.c hal_tick.h stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/device/: stm32_hal_legacy.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/: stm32f1xx_it.c
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F1/device/: stm32f1xx_hal_sd.c stm32f1xx_hal_rtc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c
  group drivers
    mbed-os/drivers/: AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
    ./obj/: analogin.o busin.o businout.o busout.o can.o ethernet.o filebase.o filelike.o filepath.o filesystemlike.o i2c.o i2cslave.o interruptin.o interruptmanager.o localfilesystem.o rawserial.o serial.o serialbase.o spi.o spislave.o stream.o ticker.o timeout.o timer.o timerevent.o
  group equeue
    mbed-os/events/equeue/: equeue.c equeue_mbed.cpp equeue_posix.c
    ./obj/: equeue.o equeue_mbed.o equeue_posix.o
  group events
    mbed-os/events/: EventQueue.cpp
    ./obj/: eventqueue.o
  group hal
    mbed-os/hal/: mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c
    ./obj/: mbed_gpio.o mbed_lp_ticker_api.o mbed_pinmap_common.o mbed_ticker_api.o mbed_us_ticker_api.o
  group inc
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
  group mbed-os
    mbed-os/: mbed.h
  group mbed-os-stm32f103
    ./: main.cpp mbed_config.h
    ./: usb.cpp
  group platform
    mbed-os/platform/: CallChain.cpp mbed_alloc_wrappers.cpp mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_mem_trace.c mbed_rtc_time.cpp mbed_semihost_api.c mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp retarget.cpp
    ./obj/: callchain.o mbed_alloc_wrappers.o mbed_assert.o mbed_board.o mbed_critical.o mbed_error.o mbed_interface.o mbed_mem_trace.o mbed_rtc_time.o mbed_semihost_api.o mbed_wait_api_no_rtos.o mbed_wait_api_rtos.o retarget.o
  group rtos
    mbed-os/rtos/: Mutex.cpp rtos_idle.c RtosTimer.cpp Semaphore.cpp Thread.cpp
    ./obj/: mutex.o rtos_idle.o rtostimer.o semaphore.o thread.o
  group ampm_lib
    ./ampm_lib/obj/: ampm_list.o ampm_sprintf.o comm.o data_cmp.o encoding.o m_time.o packet_queue.o ringbuf.o sparser.o sys_tick.o sys_time.o
    ./ampm_lib/lib/: sys_tick.c ampm_sys_tick.cpp
  group ampm_gsm
    ./ampm_lib/ampm_gsm/: ampm_gsm_main_task.c ampm_gsm.cpp ampm_gsm_api.cpp ampm_gsm_startup.c
    ./ampm_lib/obj/: ampm_gsm_call.o ampm_gsm_common.o ampm_gsm_dial_up.o ampm_gsm_io.o ampm_gsm_ring.o ampm_gsm_sms.o pdu.o at_command_parser.o
  group lwip_api
    ./EthernetInterface/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_arch
    ./EthernetInterface/lwip-sys/arch/: checksum.c memcpy.c sys_arch.c
  group lwip_core
    ./EthernetInterface/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./obj/: def.o dhcp.o dns.o init.o mem.o memp.o netif.o pbuf.o raw.o stats.o tcp.o tcp_in.o tcp_out.o timers.o udp.o
  group lwip_ipv4
    ./EthernetInterface/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./obj/: ip_frag.o ip_addr.o ip.o inet_chksum.o inet.o igmp.o icmp.o autoip.o
  group lwip_netif
    ./EthernetInterface/lwip/netif/: etharp.c ethernetif.c sio.c slipif.c
    ./obj/: slipif.o sio.o ethernetif.o etharp.o
  group lwip_ppp
    ./EthernetInterface/lwip/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
    ./obj/: auth.o chap.o chpms.o fsm.o lcp.o magic.o md5.o pap.o ppp.o ppp_oe.o randm.o vj.o ipcp.o
  group lwip_snmp
    ./EthernetInterface/lwip/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ./obj/: asn1_dec.o asn1_enc.o mib2.o msg_in.o msg_out.o mib_structs.o
  group gps
    ./ampm_lib/gps/: ampm_gps.c ampm_gps_io.cpp ampm_mbed_gps_api.cpp
